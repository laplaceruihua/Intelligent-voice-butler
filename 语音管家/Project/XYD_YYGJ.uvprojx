# Keil uVision project XYD_YYGJ.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: XYD_YYGJ
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CMSIS;..\User;..\User\API;..\LIb\inc;..\Lcd;..\LD_Driver;..\fatfs_app;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: core_cm3.c
  group USER
    ../User/: stm32f10x_it.c system_stm32f10x.c main.c
  group API
    ../User/API/: delay.c LED.c usart.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group LIB
    ../LIb/SRC/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group Lcd
    ../Lcd/: Lcd_Driver.c GUI.c
    ../User/API/: ui.c
  group LD3320
    ../User/API/: LD_Config.c LD_API.c LD_Main.c
  group SD_DRIVER
    ../User/API/: SD_Config.c SD_Driver.c fatfs_test.c
    ../fatfs_app/: fatfs_app.c
  group fatfs
    ../source/: diskio.c ff.c ffsystem.c ffunicode.c
    ../fatfs_app/: mycc936.c
software components: CMSIS:CORE 4.3.0
